<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Esercitazione 1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Mio\esercizio 1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


